<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\9 Two-Digit_Event_counter EWARM (IAR).ewp</path>
  </project>
  <batchBuild />
</workspace>
