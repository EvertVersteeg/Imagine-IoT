<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Two-Digit_LED_Counter.ewp</path>
  </project>
  <batchBuild />
</workspace>
