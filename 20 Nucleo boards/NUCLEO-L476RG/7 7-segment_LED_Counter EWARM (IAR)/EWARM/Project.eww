<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\7-Segment_LED_Counter EWARM (IAR).ewp</path>
  </project>
  <batchBuild />
</workspace>
