<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Counter_With_LEDs.ewp</path>
  </project>
  <batchBuild />
</workspace>
